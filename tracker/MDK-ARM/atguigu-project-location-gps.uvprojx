# Keil uVision project atguigu-project-location-gps.uvprojx, settings and files
target atguigu-project-location-gps (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: atguigu-project-location-gps +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./source/App;./source/Com;./source/Int;./source/Int/DS3553;./source/Int/AT6558R;./source/Int/QS100;./source/Int/LLCC68;..\..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c rtc.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ./source/App/: App_Main.c App_Main.h App_LowPower.c App_LowPower.h App_Work.c App_Work.h
  group Com
    ./source/Com/: Com_Delay.c Com_Delay.h Com_Debug.c Com_Debug.h cJSON.c cJSON.h
  group Int
    ./source/Int/DS3553/: Int_DS3553.c Int_DS3553.h
    ./source/Int/AT6558R/: Int_AT6558R.c Int_AT6558R.h
    ./source/Int/QS100/: Int_QS100.c Int_QS100.h
    ./source/Int/LLCC68/: Int_LLCC68.c Int_LLCC68.h driver_llcc68.c driver_llcc68.h driver_llcc68_interface.c driver_llcc68_interface.h
software components: CMSIS:CORE 4.3.0
